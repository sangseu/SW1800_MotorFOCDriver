# Keil uVision project SWM1800.uvproj, settings and files
target SWM1800 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: SWM1800
  AfterMake: fromelf.exe --bin -o ./out/SWM1800.bin ./out/SWM1800.axf
  c flags: Optim=1
  c include: .\CSL\CMSIS\CoreSupport;.\CSL\CMSIS\DeviceSupport;.\CSL\SWM1800_StdPeriph_Driver;.\APP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group APP
    ./APP/: Smc.c InitMcu.c FdWeak.c CalcRef.c ClrkPark.c InvPark.c MeasCurr.c Pi.c Svgen.c Trig.c PMSM.c faultprotect.c
  group CSL\StdPD
    ./CSL/SWM1800_StdPeriph_Driver/: SWM1800_adc.c SWM1800_can.c SWM1800_cmp.c SWM1800_cordic.c SWM1800_div.c SWM1800_dma.c SWM1800_exti.c SWM1800_flash.c SWM1800_gpio.c SWM1800_i2c.c SWM1800_irqmux.c SWM1800_port.c SWM1800_pwm.c SWM1800_sdadc.c SWM1800_slcd.c SWM1800_spi.c SWM1800_timr.c SWM1800_uart.c SWM1800_wdt.c SWM1800_cache.c
  group CSL\CMSIS
    ./CSL/CMSIS/CoreSupport/: core_cm0.c
    ./CSL/CMSIS/DeviceSupport/: system_SWM1800.c
    ./CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM1800.s
  group H
    ./APP/: Control.h FdWeak.h General.h MeasCurr.h Park.h Parms.h Pi.h ReadADC.h Smc.h SVGen.h swm1500_uart.h typedef.h UserParms.h
